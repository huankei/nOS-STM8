# IAR project nOS-STM8.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: C:\Users\Olivier\Git\nOS-STM8\nOS\inc; C:\Users\Olivier\Git\nOS-STM8\nOS\inc\port\IAR\STM8
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group nOS/inc
    nOS/inc/: nOS.h nOSConfig.h
  group nOS/inc/port
    nOS/inc/port/IAR/STM8/: nOSPort.h
  group nOS/src
    nOS/src/: nOSAlarm.c nOSEvent.c nOSFlag.c nOSList.c nOSMem.c nOSMutex.c nOSQueue.c nOSSched.c nOSSem.c nOSSignal.c nOSThread.c nOSTime.c nOSTimer.c
  group nOS/src/port
    nOS/src/port/IAR/STM8/: nOSPort.c nOSPortASM.s
